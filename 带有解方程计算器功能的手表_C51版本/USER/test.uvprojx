# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\TPAD;..\HARDWARE\OLED;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\LSENS;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\RS485;..\HARDWARE\CAN;..\HARDWARE\TOUCH;..\HARDWARE\REMOTE;..\HARDWARE\JOYPAD;..\HARDWARE\DS18B20;..\HARDWARE\DHT11;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\NRF24L01;..\HARDWARE\STMFLASH;..\HARDWARE\OV7725;..\HARDWARE\SRAM;..\HARDWARE\SDIO;..\HARDWARE\SPBLCD;..\HARDWARE\USART3;..\HARDWARE\SIM900A;..\FATFS\src;..\FATFS\exfuns;..\USMART;..\MALLOC;..\TEXT;..\PICTURE;..\APP;..\UCOSII\CORE;..\UCOSII\PORT;..\UCOSII\CONFIG;..\GUI;..\T9INPUT;..\ATKNCR;..\USB\CONFIG;..\USB\STM32_USB-FS-Device_Driver\inc;..\BACKGROUND;..\MENU;..\COLORSET;..\SIMPLESYS;..\TIMESET;..\NEWTOU;..\TIME;..\DRAW;..\calc;..\DRAWCALC;..\PICTUREDRAW;..\OURTEST
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x68000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/24CXX/: 24cxx.c myiic.c
    ../HARDWARE/BEEP/: beep.c
    ../UCOSII/CONFIG/: includes.h
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group GUI
    ../GUI/: button.c edit.c filelistbox.c gui.c listbox.c progressbar.c window.c scrollbar.c memo.c
  group README
    ../: README.TXT
  group NEWTOU
    ../NEWTOU/: newtouch.c newtouch.h
  group TIMESET
    ../TIMESET/: time_set.c time_set.h
  group COLORSET
    ../COLORSET/: colorset.c colorset.h
  group BACKGROUND
    ../BACKGROUND/: background.c background.h
  group SIMPLESYS
    ../SIMPLESYS/: simplesys.c simplesys.h
  group MENU
    ../MENU/: menu.c menu.h
  group TIME
    ../TIME/: time.c time.h
  group DRAW
    ../DRAW/: draw.c draw.h
  group CALC
    ../CALC/: calc.c calc.h
  group DRAWCALC
    ../DRAWCALC/: drawcalc.c drawcalc.h
  group PICTUREDRAW
    ../PICTUREDRAW/: picturedraw.c picturedraw.h
  group OURTEST
    ../OURTEST/: ourtest.c ourtest.h
